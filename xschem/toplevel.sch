v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {r2r_dac.sym} 440 -240 0 0 {name=x1}
C {iopin.sym} 160 -140 0 1 {name=p1 lab=VGND}
C {iopin.sym} 160 -340 0 1 {name=p2 lab=VPWR}
C {lab_pin.sym} 440 -180 0 1 {name=p3 sig_type=std_logic lab=VGND}
C {ipin.sym} 160 -300 0 0 {name=p4 lab=ena}
C {ipin.sym} 160 -280 0 0 {name=p5 lab=clk}
C {ipin.sym} 160 -260 0 0 {name=p6 lab=rst_n}
C {ipin.sym} 160 -220 0 0 {name=p7 lab=ui_in[7:0]}
C {ipin.sym} 160 -180 0 0 {name=p8 lab=uio_in[7:0]}
C {opin.sym} 800 -310 0 0 {name=p9 lab=uo_out[7:0]}
C {opin.sym} 800 -260 0 0 {name=p10 lab=uio_out[7:0]}
C {opin.sym} 800 -210 0 0 {name=p11 lab=uio_oe[7:0]}
C {iopin.sym} 800 -160 0 0 {name=p12 lab=ua[3:0]}
C {lab_pin.sym} 320 -240 0 0 {name=p13 sig_type=std_logic lab=ui_in[7:0]}
C {lab_pin.sym} 560 -240 0 1 {name=p14 sig_type=std_logic lab=ua[0]}
C {ignore.sym} 560 -180 0 1 {name=l1}
C {lab_pin.sym} 560 -180 0 1 {name=p15 sig_type=std_logic lab=ua[3:1]}
C {ignore.sym} 160 -340 0 0 {name=l2}
C {ignore.sym} 160 -300 0 0 {name=l3}
C {ignore.sym} 160 -280 0 0 {name=l4}
C {ignore.sym} 160 -260 0 0 {name=l5}
C {ignore.sym} 160 -180 0 0 {name=l6}
C {lab_pin.sym} 760 -310 0 0 {name=p16 sig_type=std_logic lab=8*VGND}
C {lab_pin.sym} 760 -260 0 0 {name=p17 sig_type=std_logic lab=8*VGND}
C {lab_pin.sym} 760 -210 0 0 {name=p18 sig_type=std_logic lab=8*VGND}
C {shorted.sym} 780 -310 0 0 {name=R1[7:0] value=0.1}
C {shorted.sym} 780 -260 0 0 {name=R2[7:0] value=0.1}
C {shorted.sym} 780 -210 0 0 {name=R3[7:0] value=0.1}
